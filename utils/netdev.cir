R3 vcc 5V 1.0K
R1 vcc intb 10.0mEG
R2 intb 0 100.0m
Cout out 5V 1000.0mil
Cin intb in 10000.0e
C2 intb in 10e000.0e
C3 intb in 10e000.0n
